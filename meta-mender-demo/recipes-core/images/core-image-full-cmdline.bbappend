IMAGE_INSTALL_append = " hello-mender boot-script"
